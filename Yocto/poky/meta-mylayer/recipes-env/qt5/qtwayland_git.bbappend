PACKAGECONFIG:remove:pn-qtwayland = "xcomposite-glx"
