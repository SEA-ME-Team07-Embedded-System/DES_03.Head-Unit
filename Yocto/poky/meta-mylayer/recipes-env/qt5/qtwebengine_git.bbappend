EXTRA_OECONF:append = " -no-webengine-jumbo-build"

NINJAFLAGS = "-j8"
