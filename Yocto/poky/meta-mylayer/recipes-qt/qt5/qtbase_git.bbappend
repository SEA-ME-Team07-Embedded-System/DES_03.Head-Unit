PACKAGECONFIG:append = " examples gles2 eglfs fontconfig"
DEPENDS += "userland"
